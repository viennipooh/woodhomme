<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>D:\1_Poj\6_Pixel\project\pixel-imc-ftx.ewp</path>
    </project>
    <batchBuild />
</workspace>
