<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>D:\1_Poj\1_IIP\IIP30_INA\project\iip.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\imc-ftx-mc_f4.ewp</path>
  </project>
  <batchBuild/>
</workspace>


