# IAR project Backup of imc-ftx-mc_f4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F427VI ST STM32F427VI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F427_437xx; STM32; VER_MAJ=$PROJ_VER_MAJ$; VER_MIN=$PROJ_VER_MIN$; VER_DATE=$DATE$; VER_CONF=$CONFIG_NAME$
  ICCARM.CCIncludePath2: ..\sources\; ..\sources\services; ..\sources\httpd\; ..\sources\snmp\; ..\sources\settings\; ..\sources\Devices\ModbusCRC16; ..\sources\drivers; ..\sources\drivers\inc; ..\sources\drivers\CMSIS\Include; ..\sources\config; ..\sources\rarp; ..\libraries\STM32F4x7_ETH_Driver\inc; ..\libraries\STM32F4xx_StdPeriph_Driver\inc; ..\utilities\FreeRTOSV7.3.0\include; ..\utilities\FreeRTOSV7.3.0\portable\IAR\ARM_CM4F; ..\utilities; ..\utilities\ff11a\src; ..\utilities\lwip-2.0.2\port\STM32F4x7; ..\utilities\lwip-2.0.2\port\STM32F4x7\arch; ..\utilities\lwip-2.0.2\port\STM32F4x7\FreeRTOS; ..\utilities\lwip-2.0.2\src\include; ..\utilities\lwip-2.0.2\src\include\lwip; ..\utilities\lwip-2.0.2\src\include\lwip\priv; ..\utilities\lwip-2.0.2\src\include\lwip\prot; ..\utilities\lwip-2.0.2\src\include\netif; ..\utilities\lwip-2.0.2\src\include\posix; ..\utilities\lwip-2.0.2\src\include\posix\sys; ..\utilities\lwip-2.0.2\src\apps\snmp; ..\utilities\lwip-2.0.2\src\apps\ping; ..\utilities\lwip-2.0.2\src\include\lwip\apps; ..\utilities\lwip-2.0.2\src\apps\sntp; ..\sources\vlan; ..\sources\stp; ..\sources\log
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\sources\config; ..\utilities\FreeRTOSV7.3.0\include; ..\utilities\FreeRTOSV7.3.0\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: imc-ftx-mc_f4-$PROJ_VER_MAJ$.$PROJ_VER_MIN$-$DATE$-$CONFIG_NAME$.bin
  ILINK.IlinkOutputFile: stm32f4x7_template.out
  ILINK.IlinkIcfFile: stm32f429xI_bl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group libraries/STM32F4xx_StdPeriph_Driver
    ../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_syscfg.c
  group sources
    ../sources/: main.c main.h mbcrc.c mbcrc.h mode.c sw_reg.c
  group sources/config
    ../sources/config/: defconf.h FreeRTOSConfig.h lwipopts.h netconf.c netconf.h startup_stm32f4xx.s stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h
  group sources/drivers
    ../sources/drivers/: at45db.c at45db_disk.c at45db_disk.h bkpsram.c bkpsram.h can.c common.h diskio.c err_hw.h eth.c eth.h eth_mac.h eth_phy.h ethernetif.c ethernetif.h extio.c extio.h flash.c flash.h ksz8895fmq.c ksz8895fmq.h stm32eth_mac.c stm32eth_regs.h switch.c switch.h
    ../sources/services/: temp_ctrl.c
  group sources/drivers/inc
    ../sources/drivers/inc/: dma.h otp.h spi.h stm32eth.h stm32eth_regs.h usart.h
  group sources/drivers/src
    ../sources/drivers/src/: dma.c otp.c spi.c stm32eth.c usart.c
  group sources/httpd
    ../sources/httpd/: base64.c base64.h fs.c fs.h fs_custom.c fsdata.c fsdata.h httpd.c httpd.h httpd_cgi_ssi.c httpd_post.c httpd_structs.h sha1.c
  group sources/log
    ../sources/log/: log.c log_flash.c
  group sources/rarp
    ../sources/rarp/: rarp.c
  group sources/service
    ../sources/services/: adc_ctrl.c cable.c db.c db.h db_bkpsram.c db_flash.c db_sram.c default_reset.c iperf_server.c iperf_server.h ld_api.h service.c service.h statistics.c statistics.h vcc_ctrl.c
  group sources/settings
    ../sources/settings/: dev_param.c dev_param.h info.c info.h settings.c settings.h settings_ll.c settings_serial.c settings_switch.c settings_tcpudp.c
  group sources/snmp
    ../sources/snmp/: my_mibs.c my_mibs.h snmp_trap.c
  group sources/stp
    ../sources/stp/: stp.cpp
  group sources/vlan
    ../sources/vlan/: vlan.c
  group utilities
    ../utilities/: base64.c base64.h crc.c crc.h md5.c md5.h
  group utilities/ff11a/src
    ../utilities/ff11a/src/: diskio.h ff.c ff.h ffconf.h fw.c integer.h
  group utilities/ff11a/src/option
    ../utilities/ff11a/src/option/: unicode.c
  group utilities/FreeRTOSV7.3.0
    ../utilities/FreeRTOSV7.3.0/: croutine.c list.c queue.c tasks.c timers_rtos.c
  group utilities/FreeRTOSV7.3.0/include
    ../utilities/FreeRTOSV7.3.0/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group utilities/FreeRTOSV7.3.0/portable/IAR/ARM_CM4F
    ../utilities/FreeRTOSV7.3.0/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group utilities/FreeRTOSV7.3.0/portable/MemMang
    ../utilities/FreeRTOSV7.3.0/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c
  group utilities/lwip-2.0.2/ping
    ../utilities/lwip-2.0.2/src/apps/ping/: ping.c
  group utilities/lwip-2.0.2/port/STM32F4x7/arch
    ../utilities/lwip-2.0.2/port/STM32F4x7/arch/: bpstruct.h cc.h cpu.h epstruct.h init.h lib.h perf.h sys_arch.h
  group utilities/lwip-2.0.2/port/STM32F4x7/FreeRTOS
    ../utilities/lwip-2.0.2/port/STM32F4x7/FreeRTOS/: ethernetif.h sys_arch.c sys_arch.h
  group utilities/lwip-2.0.2/port/STM32F4x7/Standalone
    ../utilities/lwip-1.4.1/port/STM32F4x7/Standalone/: ethernetif.c ethernetif.h
  group utilities/lwip-2.0.2/snmp/inc
    ../utilities/lwip-2.0.2/src/include/lwip/apps/: snmp.h snmp_core.h snmp_mib2.h snmp_opts.h snmp_scalar.h snmp_snmpv2_framework.h snmp_snmpv2_usm.h snmp_table.h snmp_threadsync.h snmpv3.h
    ../utilities/lwip-2.0.2/src/apps/snmp/: snmp_asn1.h snmp_core_priv.h snmp_msg.h snmp_pbuf_stream.h snmpv3_priv.h
  group utilities/lwip-2.0.2/snmp/src
    ../utilities/lwip-2.0.2/src/apps/snmp/: snmp_asn1.c snmp_core.c snmp_mib2.c snmp_mib2_icmp.c snmp_mib2_interfaces.c snmp_mib2_ip.c snmp_mib2_snmp.c snmp_mib2_system.c snmp_mib2_tcp.c snmp_mib2_udp.c snmp_msg.c snmp_netconn.c snmp_pbuf_stream.c snmp_raw.c snmp_scalar.c snmp_snmpv2_framework.c snmp_snmpv2_usm.c snmp_table.c snmp_threadsync.c snmp_traps.c snmpv3.c snmpv3_mbedtls.c
  group utilities/lwip-2.0.2/sntp
    ../utilities/lwip-2.0.2/src/apps/sntp/: ntp_conv.c sntp.c
  group utilities/lwip-2.0.2/src/api
    ../utilities/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group utilities/lwip-2.0.2/src/core
    ../utilities/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group utilities/lwip-2.0.2/src/core/ipv4
    ../utilities/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group utilities/lwip-2.0.2/src/include/lwip
    ../utilities/lwip-2.0.2/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group utilities/lwip-2.0.2/src/include/lwip/priv
    ../utilities/lwip-2.0.2/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
  group utilities/lwip-2.0.2/src/include/lwip/prot
    ../utilities/lwip-2.0.2/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group utilities/lwip-2.0.2/src/include/netif
    ../utilities/lwip-2.0.2/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group utilities/lwip-2.0.2/src/include/posix
    ../utilities/lwip-2.0.2/src/include/posix/: errno.h netdb.h
  group utilities/lwip-2.0.2/src/include/posix/sys
    ../utilities/lwip-2.0.2/src/include/posix/sys/: socket.h
  group utilities/lwip-2.0.2/src/netif
    ../utilities/lwip-2.0.2/src/netif/: ethernet.c lowpan6.c slipif.c
